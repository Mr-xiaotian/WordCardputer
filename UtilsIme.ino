/**
 * @file UtilsIme.ino
 * @brief 日语输入法（IME）工具函数
 *
 * 提供罗马音到假名的转换功能，包含完整的罗马音映射表
 * （清音、浊音、半浊音、拗音、长音），以及 UTF-8 字符串
 * 末尾字符删除功能，用于支持日语听写模式的输入处理。
 */

/**
 * 提交当前候选假名到已确认文本
 *
 * 将当前罗马音缓冲区匹配到的候选假名追加到 commitText 中，
 * 并清空罗马音缓冲区和候选假名。由分号键或 Enter 键触发。
 * 若当前无候选假名则不做任何操作。
 */
void commitCandidate()
{
    if (candidateKana.length() > 0)
    {
        commitText += candidateKana;
        romajiBuffer = "";
        candidateKana = "";
    }
}

/**
 * 判断字符是否可以形成促音（双辅音）
 *
 * 在日语罗马音输入中，连续输入相同的辅音（如 kk、ss、tt、pp）
 * 会触发促音「っ/ッ」的输入。本函数判断给定字符是否属于
 * 可以产生促音的辅音字母（k、s、t、p）。
 *
 * @param c 待检测的字符（小写字母）
 * @return 该字符是否为可产生促音的辅音
 */
bool isSokuonConsonant(char c) {
    return c=='k' || c=='s' || c=='t' || c=='p';
}

/**
 * 罗马音映射表条目结构体
 *
 * 每条记录包含一个罗马音拼写及其对应的平假名和片假名。
 */
struct RomajiMap
{
    const char *romaji;
    const char *hira; // 平假名
    const char *kata; // 片假名
};

/**
 * 罗马音到假名的完整映射表
 *
 * 包含日语五十音图的所有基本音节映射：
 * - 清音（あ行 ~ わ行）
 * - 浊音（が行、ざ行、だ行、ば行）
 * - 半浊音（ぱ行）
 * - 拗音（きゃ行、しゃ行、ちゃ行等）
 * - 长音符号（ー）
 */
static const RomajiMap ROMAJI_TABLE[] = {

    // --- 清音 ---
    {"a", "あ", "ア"},  {"i", "い", "イ"},  {"u", "う", "ウ"},  {"e", "え", "エ"},  {"o", "お", "オ"},
    {"ka", "か", "カ"}, {"ki", "き", "キ"}, {"ku", "く", "ク"}, {"ke", "け", "ケ"}, {"ko", "こ", "コ"},
    {"sa", "さ", "サ"}, {"si", "し", "シ"}, {"su", "す", "ス"}, {"se", "せ", "セ"}, {"so", "そ", "ソ"},
    {"ta", "た", "タ"}, {"ti", "ち", "チ"}, {"tu", "つ", "ツ"}, {"te", "て", "テ"}, {"to", "と", "ト"},
    {"na", "な", "ナ"}, {"ni", "に", "ニ"}, {"nu", "ぬ", "ヌ"}, {"ne", "ね", "ネ"}, {"no", "の", "ノ"},
    {"ha", "は", "ハ"}, {"hi", "ひ", "ヒ"}, {"hu", "ふ", "フ"}, {"he", "へ", "ヘ"}, {"ho", "ほ", "ホ"},
    {"ma", "ま", "マ"}, {"mi", "み", "ミ"}, {"mu", "む", "ム"}, {"me", "め", "メ"}, {"mo", "も", "モ"},
    {"ya", "や", "ヤ"}, {"yu", "ゆ", "ユ"}, {"yo", "よ", "ヨ"},
    {"ra", "ら", "ラ"}, {"ri", "り", "リ"}, {"ru", "る", "ル"}, {"re", "れ", "レ"}, {"ro", "ろ", "ロ"},
    {"wa", "わ", "ワ"}, {"wo", "を", "ヲ"}, {"n", "ん", "ン"},

    // --- 浊音 ---
    {"ga", "が", "ガ"}, {"gi", "ぎ", "ギ"}, {"gu", "ぐ", "グ"}, {"ge", "げ", "ゲ"}, {"go", "ご", "ゴ"},
    {"za", "ざ", "ザ"}, {"zi", "じ", "ジ"}, {"zu", "ず", "ズ"}, {"ze", "ぜ", "ゼ"}, {"zo", "ぞ", "ゾ"},
    {"da", "だ", "ダ"}, {"di", "ぢ", "ヂ"}, {"du", "づ", "ヅ"}, {"de", "で", "デ"}, {"do", "ど", "ド"},
    {"ba", "ば", "バ"}, {"bi", "び", "ビ"}, {"bu", "ぶ", "ブ"}, {"be", "べ", "ベ"}, {"bo", "ぼ", "ボ"},

    // --- 半浊音 ---
    {"pa", "ぱ", "パ"}, {"pi", "ぴ", "ピ"}, {"pu", "ぷ", "プ"}, {"pe", "ぺ", "ペ"}, {"po", "ぽ", "ポ"},
    
    // --- 拗音 --- 
    {"kya", "きゃ", "キャ"}, {"kyu", "きゅ", "キュ"}, {"kyo", "きょ", "キョ"}, 
    {"sha", "しゃ", "シャ"}, {"shu", "しゅ", "シュ"}, {"sho", "しょ", "ショ"}, 
    {"cha", "ちゃ", "チャ"}, {"chu", "ちゅ", "チュ"}, {"cho", "ちょ", "チョ"},
    {"nya", "にゃ", "ニャ"}, {"nyu", "にゅ", "ニュ"}, {"nyo", "にょ", "ニョ"}, 
    {"hya", "ひゃ", "ヒャ"}, {"hyu", "ひゅ", "ヒュ"}, {"hyo", "ひょ", "ヒョ"},
    {"mya", "みゃ", "ミャ"}, {"myu", "みゅ", "ミュ"}, {"myo", "みょ", "ミョ"},
    {"rya", "りゃ", "リャ"}, {"ryu", "りゅ", "リュ"}, {"ryo", "りょ", "リョ"},
    {"ja", "じゃ", "ジャ"},  {"ju", "じゅ", "ジュ"},  {"jo", "じょ", "ジョ"},
    {"bya", "びゃ", "ビャ"}, {"byu", "びゅ", "ビュ"}, {"byo", "びょ", "ビョ"},
    {"pya", "ぴゃ", "ピャ"}, {"pyu", "ぴゅ", "ピュ"}, {"pyo", "ぴょ", "ピョ"},

    // --- 长音 ---
    {"-", "", "ー"},
};

/** 映射表条目总数 */
static const int ROMAJI_TABLE_SIZE = sizeof(ROMAJI_TABLE) / sizeof(ROMAJI_TABLE[0]);

/**
 * 在罗马音映射表中查找匹配的假名
 *
 * 将输入的罗马音缓冲区内容与映射表逐条比较（忽略大小写），
 * 如果找到完全匹配的条目，则根据当前输入模式返回对应的
 * 平假名或片假名。不修改传入的缓冲区，仅做只读查询。
 *
 * @param buffer 当前罗马音输入缓冲区
 * @param useKatakana 为 true 时返回片假名，为 false 时返回平假名
 * @return 匹配到的假名字符串，未匹配时返回空字符串
 */
String matchRomaji(const String &buffer, bool useKatakana)
{
    if (buffer.length() == 0)
        return "";

    for (int i = 0; i < ROMAJI_TABLE_SIZE; ++i)
    {
        if (buffer.equalsIgnoreCase(ROMAJI_TABLE[i].romaji))
        {
            String candidate = useKatakana ? ROMAJI_TABLE[i].kata : ROMAJI_TABLE[i].hira;
            return String(candidate);
        }
    }
    return "";
}

/**
 * 删除 UTF-8 字符串末尾的一个完整字符
 *
 * 从字符串末尾向前扫描，跳过所有 UTF-8 后续字节（10xxxxxx），
 * 定位到最后一个字符的起始字节，然后将其及之后的内容全部移除。
 * 可正确处理多字节 UTF-8 字符（如中文、日文假名等）。
 *
 * @param s 要操作的字符串引用，会被直接修改
 */
void removeLastUTF8Char(String &s)
{
    int len = s.length();
    if (len == 0)
        return;

    // UTF-8 末尾字节判断（10xxxxxx = continuation）
    int i = len - 1;
    while (i >= 0 && ((s[i] & 0b11000000) == 0b10000000))
    {
        i--;
    }

    // i 现在停在字符的起始字节
    s.remove(i);
}
